# Keil uVision project lab4.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: lab4 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Delay;.\Keyboard;.\Nixie;.\Timer;.\Ds18b20
  group Source Group 1
    ./Delay/: delay.c delay.h
    ./Keyboard/: keyboard.c keyboard.h
    ./: main.c
    ./Nixie/: nixie.c nixie.h
    ./Timer/: timer.c timer.h
    ./Ds18b20/: ds18b20.c ds18b20.h
